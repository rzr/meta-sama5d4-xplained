FILESEXTRAPATHS_prepend := "${THISDIR}/qtwayland:"
SRC_URI += "file://qt_touch_workaround.patch"
